# Repository ZeshuLiu/PolaMiya

File ReadMe.md:

# PolaMiya - 宝丽来相机改装项目

**代码仓库：[PolaMiyaSoftware](https://github.com/ZeshuLiu/PolaMiyaSoftware)**

**硬件仓库（电路及结构）：[PolaMiyaHardware](https://github.com/ZeshuLiu/PolaMiyaHardware)**

> 本仓库保留项目整体说明，代码和硬件设计文件已分别迁移至上述独立仓库。

宝丽来相机一台，具有测距、电动吐片等功能。

## 已实现功能

1. 电动吐片
2. 激光测距
3. 温度显示（核心 PCB 及芯片温度）
4. 屏幕显示控制
5. 闪光灯控制（经 MCU）

## 说明

项目比较简单，需要采购的大件只有两个：
- Mamiya Press 127mm 镜头（不需要调焦桶）
- 宝丽来 AF5000（需要里面的吐片下巴、吐片电机和齿轮组）

详细的结构件和装配说明请参考 **[PolaMiyaHardware](https://github.com/ZeshuLiu/PolaMiyaHardware)** 仓库。

## 硬件设计

电路及结构设计文件位于 **[PolaMiyaHardware](https://github.com/ZeshuLiu/PolaMiyaHardware)** 仓库，包含：
- PCB 设计
- 3D 打印结构件
- 装配图纸

## 软件代码

源代码位于 **[PolaMiyaSoftware](https://github.com/ZeshuLiu/PolaMiyaSoftware)** 仓库，包含：
- 主控器固件（MainController2）
- 电源管理固件（PowerManage2）
- CubeMX 配置及 Keil uVision 工程

## 使用方法

机身左下角按钮长按 2 秒开机或关机；三向按钮长按中键 2 秒吐片电机开始运行，随后短按吐片电机停止；在吐片电机运行时推动侧面推杆，相纸即吐出；测距开机即运行。

## 样片

## 后续计划

1. 测光
2. 全息取景器（已开始设计）

## 已知问题

1. 吐片口密封性能不好，严禁在有相纸的情况下打开片仓（不中途打开片仓密封性没有问题）

## 已修复问题

1. （主控器 Rev1.0 硬件）相机吐片电机运行后会导致测距停止，该问题由硬件导致，已经在 Rev1.2 硬件中修复
2. （主控器 Rev1.0 硬件）温度传感器布置位置不合理，测得的温度受芯片运行发热影响较大。已经在 Rev1.2 硬件中修复

## KiCad design 电路/电机驱动/MotroDrive/MotroDrive.kicad_pcb

Board: 2 copper layers, 33.0 x 48.0 mm, 19 parts (0 on the bottom side), 10 nets.

Parts:
C1: 10uf; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C2: 1uf; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C4: 100uf; CP_Elec_6.3x7.7
D2: SS34; D_SMA
D3: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D4: 1N5819WS; D_SOD-323_HandSoldering
FB1: FerriteBead; L_0603_1608Metric
H1, H2, H4: MountingHole; MountingHole_3.2mm_M3
J1: Conn_01x04_MountingPin; JST_PH_S4B-PH-SM4-TB_1x04-1MP_P2.00mm_Horizontal
J2: Conn_01x02_MountingPin; JST_PH_S2B-PH-SM4-TB_1x02-1MP_P2.00mm_Horizontal
L2: 4.7uH; L_APV_APH1265
Q1: AO3400A; SOT-23
R1: 330k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2: 51k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R4: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5: 1k; R_0603_1608Metric
U1: TLV61048DBVR; SOT-23-6_DBV_TEX

Connections:
+BATT: C2.1, C4.1, D3.1 (K), J1.4, L2.1, R5.1, U1.5 (VIN)
/MT_EN: J1.2, Q1.1 (G)
/Motor+: C1.1, D2.1 (K), D4.1 (K), J2.2, R1.1
/POWER_GND: C4.2, FB1.2, J1.1, Q1.2 (S)
/SW: D2.2 (A), L2.2, U1.1 (SW)
GND: C1.2, C2.2, D4.2 (A), J2.1, J2.MP (MountPin), Q1.3 (D), R2.2, R4.2, U1.2 (GND)
unnamed: D3.2 (A), R4.1
unnamed: FB1.1, J1.3
unnamed: R5.2, U1.4 (EN)
unnamed: R1.2, R2.1, U1.3 (FB)

File 电路/电机驱动/MotroDrive/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
C1,1206,1,10uf,
C2,1206,1,1uf,
C4,CP_Elec_6.3x7.7,1,100uf,
"D1, D4",D_SOD-323_HandSoldering,2,1N5819WS,
D3,0805,1,LED,
FB1,0603,1,FerriteBead,
J1,JST_PH_S4B-PH-SM4-TB_1x04-1MP_P2.00mm_Horizontal,1,Conn_01x04_MountingPin,
J2,JST_PH_S2B-PH-SM4-TB_1x02-1MP_P2.00mm_Horizontal,1,Conn_01x02_MountingPin,
L2,L_APV_APH1265,1,4.7uH,
Q1,SOT-23,1,AO3400A,
R1,0603,1,330k,
R2,0603,1,51k,
R4,0603,1,10k,
R5,0603,1,1k,
U1,SOT-23-6_DBV_TEX,1,TLV61048DBVR,

## KiCad design 电路/主控器/PM_Controller/PM_Controller.kicad_pcb

Parts:
BT1: Battery_Cell; cr1220
C1, C2, C3, C25: 5pf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C4: 100nf; C_0603_1608Metric
C5, C6, C11, C38: 22uf; CP_EIA-3528-21_Kemet-B_Pad1.50x2.35mm_HandSolder
C7, C21, C23, C26, C28, C29, C30, C31, C33, C36, C37: 100nf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C8, C22, C27: 10uf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C10, C32, C34, C35: 1uf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C12: 22uf; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C14, C24: 47uf; CP_EIA-3528-21_Kemet-B_Pad1.50x2.35mm_HandSolder
C17, C18, C19, C20: 22uf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C39: 22uf; CP_EIA-3528-21_Kemet-B_HandSolder
C40: 1uf; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C41: 10uf; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
CHG1: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D1: SS34; D_SMA
D3: SS32; D_SMA_Handsoldering
D4: 1N5819WS; D_SOD-323_HandSoldering
FB1: FerriteBead; L_0805_2012Metric_Pad1.05x1.20mm_HandSolder
FLASH1: Conn_01x02_Pin; SolderWire-0.1sqmm_1x02_P3.6mm_D0.4mm_OD1mm_Relief
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
H5, H6, H7, H8, H9: MountingHole_Pad; MountingHole_3.2mm_M3_DIN965_Pad_TopBottom
J1, J4: Conn_01x04_Socket; JST_PH_S4B-PH-K_1x04_P2.00mm_Horizontal
J2, J3, J9: Conn_01x04_Socket; PinHeader_1x04_P2.54mm_Vertical
J5: Conn_01x02_Pin; SolderWire-0.5sqmm_1x02_P4.8mm_D0.9mm_OD2.3mm
J6: Conn_01x02_Pin; PinSocket_1x02_P2.00mm_Vertical
J7, J10: Conn_02x04_Odd_Even; PinHeader_2x04_P1.27mm_Vertical
J8: Conn_01x04_Pin; PinHeader_1x04_P2.00mm_Vertical
J11: Conn_02x06_Odd_Even; PinHeader_2x06_P1.27mm_Vertical
JP1, JP2: SolderJumper_3_Bridged12; SolderJumper-3_P1.3mm_Bridged12_Pad1.0x1.5mm
L1, L2, L3: 4.7uH; L_APV_APH0650
NRST1, NRST2: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
P3V3: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
PW_LED1: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
Q2, Q3, Q5, Q6: AO3400A; SOT-23
R1, R2, R8, R12, R14, R15, R23, R24, R27, R28, R31, R39, R41, R42: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3: RPORG(1k); R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R4, R13: 1.5k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5, R37: 22k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R6, R25, R26, R32, R40: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R7, R29, R33, R34, R35, R36, R45: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R16, R17, R18, R20, R21, R22: 100k(NC); R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R30, R38, R43: 150k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R44: 33k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U1, U9: AT24CS08-SSHM; SOIC-8_3.9x4.9mm_P1.27mm
U2: AMS1117-3.3; SOT-223-3_TabPin2
U3: STM32G431RBTx; LQFP-64_10x10mm_P0.5mm
U5: BQ21040DBV; SOT-23-6_Handsoldering
U6, U11: TPS2552DDBVR; DBV0006A_TEX
U7: STM32L011D4Px; TSSOP-14_4.4x5mm_P0.65mm
U8: ME6211C25M5; SOT-23-5_HandSoldering
U10: TMP102xxDRL; SOT-563
U12: TLP127; MFSOP6-4_4.4x3.6mm_P1.27mm
U13: TLV61048DBVR; SOT-23-6_DBV_TEX
Y1: 32.768kHz; Crystal_C26-LF_D2.1mm_L6.5mm_Horizontal
Y2: 24Mhz; Crystal_DS26_D2.0mm_L6.0mm_Horizontal

Connections:
+2V5: C20.1, C21.1, C22.1, J4.3, R13.2, R16.2, R17.2, U7.10 (VDD), U8.5 (V_{OUT})
+3.3V: C12.1, C18.1, C24.1, C27.1, C28.1, C29.1, C30.1, C31.1, C34.2, C35.2, C36.2, FB1.1, J7.7, J8.1, J10.7, J11.11, J11.12, JP2.3 (B), P3V3.2 (B), R20.2, R21.2, R22.1, R28.2, R33.1, R34.1, R35.1, R36.1, R42.1, U1.8 (VCC), U2.2 (VO), U3.16 (VDD), U3.32 (VDD), U3.48 (VDD), U3.64 (VDD), U9.8 (VCC), U10.5 (V+)
+5V: C14.1, C39.1, C41.1, D1.1 (K), D4.1 (K), L2.1, R43.1
+5VA: C5.1, C10.1, D1.2 (A), J1.1, R30.2, R38.2, U5.6 (VIN)
+BATT: C6.1, C7.1, C8.1, C19.1, C37.1, J4.1, R4.2, R8.1, R41.1, U5.2 (OUT), U6.1 (IN), U8.1 (V_{IN}), U8.3 (CE), U11.1 (IN)
/#CHRG: CHG1.1 (K), U5.3 (~CHG)
/ADC1_15: R25.1, U3.24 (PB0)
/BAT_OUT: C11.1, C40.1, L1.1, R23.2, R45.2, U6.6 (OUT), U13.5 (VIN)
/BAT_OUT2: C38.1, L3.2, U11.6 (OUT)
/BLK: J7.8, R22.2, U3.55 (PD2)
/BOOT0: JP2.2 (C), U3.61 (PB8)
/C2P0: Q6.3 (D), R17.1, U7.11 (PA9)
/C2P1: Q5.3 (D), R16.1, U7.12 (PA10)
/D_CS: J7.6, U3.62 (PB9)
/D_DC: J7.4, U3.60 (PB7)
/D_RES: J7.2, U3.59 (PB6)
/D_SCL: J7.5, U3.56 (PB3)
/D_SDA: J7.3, U3.58 (PB5)
/EJCMT_EN: R6.1, U3.20 (PA6)
/FLASH_Trig: FLASH1.1, U12.6
/HSE+: C3.1, U3.5 (PF0), Y2.1
/HSE-: C25.1, U3.6 (PF1), Y2.2
/I2C2_SCL: J10.2, R34.2, U1.6 (SCL), U3.43 (PA9), U9.6 (SCL), U10.1 (SCL)
/I2C2_SDA: J10.4, R33.2, U1.5 (SDA), U3.42 (PA8), U9.5 (SDA), U10.6 (SDA)
/I2C3_SCL: J11.3, R35.2, U3.40 (PC8)
/I2C3_SDA: J11.5, R36.2, U3.41 (PC9)
/KEY0: J10.6, U3.12 (PA0)
/KEY1: J10.8, U3.13 (PA1)
/KEY2: J10.5, U3.18 (PA4)
/KEY3: J10.3, U3.21 (PA7)
/LPRX1: J9.2, U3.8 (PC0)
/LPTX1: J9.3, U3.9 (PC1)
/LSE+: C1.1, U3.3 (PC14), Y1.1
/LSE-: C2.1, U3.4 (PC15), Y1.2
/NRST1: C26.2, NRST2.2 (B), U3.7 (PG10)
/P2C0: Q3.3 (D), R20.1, U3.34 (PB12)
/P2C1: Q2.3 (D), R21.1, U3.35 (PB13)
/PC5: J11.10, U3.23 (PC5)
/PWR_EN: R8.2, U6.3 (#EN), U7.3 (PC15)
/PWR_EN_2: R41.2, U3.22 (PC4), U11.3 (#EN)
/PWR_KEY: R32.1, U7.8 (PA7)
/PWR_LED: PW_LED1.1 (K), U7.2 (PC14)
/PWR_SENS: R40.1, U3.11 (PC3)
/RX2: J8.3, U3.17 (PA3)
/RX3: J11.7, U3.33 (PB11)
/SHUT_Trig+: J6.1, JP1.3 (B), U3.19 (PA5)
/SPI3_MISO: J11.6, U3.53 (PC11)
/SPI3_MOSI: J11.8, U3.54 (PC12)
/SPI3_SCK: J11.4, U3.52 (PC10)
/SWCLK0: J3.3, U7.14 (PA14)
/SWCLK1: J2.3, U3.50 (PA14)
/SWDIO0: J3.2, U7.13 (PA13)
/SWDIO1: J2.2, U3.49 (PA13)
/TX2: J8.2, U3.14 (PA2)
/TX3: J11.9, U3.30 (PB10)
/UD+: J1.3, U3.46 (PA12)
/UD-: J1.2, U3.45 (PA11)
/WKUP: J4.2, R18.1, U7.5 (PA0)
/_C2P0_: Q6.1 (G), R2.1, U3.36 (PB14)
/_C2P1_: Q5.1 (G), R1.1, U3.37 (PB15)
/_FLASH_Trig_: JP1.1 (A), R26.1
/_P2C0_: Q3.1 (G), R14.1, U7.6 (PA1)
/_P2C1_: Q2.1 (G), R15.1, U7.7 (PA4)
GND: BT1.2 (-), C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C10.2, C11.2, C12.2, C14.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.1, C24.2, C25.2, C26.1, C27.2, C28.2, C29.2, C30.2, C31.2, C32.1, C33.1, C34.1, C35.1, C36.1, C37.2, C38.2, C39.2, C40.2, C41.2, FLASH1.2, H5.1, H6.1, H7.1, H8.1, H9.1, J1.4, J2.4, J3.4, J4.4, J5.2, J7.1, J8.4, J9.4, J10.1, J11.1, J11.2, NRST1.1 (A), NRST2.1 (A), Q2.2 (S), Q3.2 (S), Q5.2 (S), Q6.2 (S), R1.2, R2.2, R3.2, R5.2, R7.2, R12.2, R14.2, R15.2, R18.2, R24.1, R27.2, R29.2, R31.1, R37.2, R39.1, R44.2, U1.4 (GND), U1.7 (WP), U2.1 (GND), U3.15 (VSS), U3.27 (VSSA), U3.31 (VSS), U3.47 (VSS), U3.63 (VSS), U5.5 (GND), U6.2 (GND), U7.9 (VSS), U8.2 (V_{SS}), U9.4 (GND), U9.7 (WP), U10.2 (GND), U10.4 (ADD0), U11.2 (GND), U12.3, U12.4, U13.2 (GND)
unnamed: BT1.1 (+), D3.2 (A)
unnamed: CHG1.2 (A), R4.1
unnamed: D3.1 (K), U3.1 (VBAT)
unnamed: D4.2 (A), L1.2, U13.1 (SW)
unnamed: J2.1, P3V3.1 (A)
unnamed: J5.1, R6.2
unnamed: J6.2, R42.2
unnamed: J9.1, L3.1
unnamed: JP1.2 (C), U12.1
unnamed: JP2.1 (A), R29.1
unnamed: C23.2, NRST1.2 (B), U7.4 (NRST)
unnamed: PW_LED1.2 (A), R13.1
unnamed: R23.1, R24.2, R25.2
unnamed: R30.1, R31.2, R32.2
unnamed: R38.1, R39.2, R40.2
unnamed: R27.1, U1.3 (A2)
unnamed: C17.1, L2.2, U2.3 (VI)
unnamed: R26.2, U3.51 (PA15)
unnamed: C32.2, C33.2, FB1.2, U3.28 (VREF+), U3.29 (VDDA)
unnamed: R3.1, U5.4 (ISET)
unnamed: R7.1, U5.1 (TS)
unnamed: R5.1, U6.5 (ILIM)
unnamed: R12.1, U7.1 (PB9)
unnamed: R28.1, U9.3 (A2)
unnamed: R37.1, U11.5 (ILIM)
unnamed: R45.1, U13.4 (EN)
unnamed: C4.1, R43.2, R44.1, U13.3 (FB)

Notes on the sheet:
EEPROM
电源管理
接口电平
上下拉
G474RETx 应该可用
相机功能
LDO
电池充电、升压
预留电源输出

Board: 4 copper layers, 90.0 x 61.5 mm, 132 parts (59 on the bottom side), 91 nets.

File 电路/主控器/PM_Controller/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
BT1,cr1220,1,Battery_Cell,
"C1_2, C2_2, C25, C3",0603,4,5pf,
"C1, C41",1206,2,10uf,
"C10, C32, C34, C35",0603,4,1uf,
"C11, C38, C5, C6",CP_EIA-3528-21_Kemet-B_Pad1.50x2.35mm_HandSolder,4,22uf,
C12,1206,1,22uf,
"C14, C24",CP_EIA-3528-21_Kemet-B_Pad1.50x2.35mm_HandSolder,2,47uf,
"C17, C18, C19, C20",0603,4,22uf,
"C2, C40",1206,2,1uf,
"C21, C23, C26, C28, C29, C30, C31, C33, C36, C37, C4_2, C7",0603,12,100nf,
"C22, C27, C8",0603,3,10uf,
C39,CP_EIA-3528-21_Kemet-B_HandSolder,1,22uf,
C4,CP_Elec_6.3x7.7,1,100uf,
"CHG1, D3, PW_LED1",0805,3,LED,
D1_2,D_SMA,1,SS34,
"D1, D4_2, D4",D_SOD-323_HandSoldering,3,1N5819WS,
D3_2,D_SMA_Handsoldering,1,SS32,
FB1_2,0805,1,FerriteBead,
FB1,0603,1,FerriteBead,
FLASH1,SolderWire-0.1sqmm_1x02_P3.6mm_D0.4mm_OD1mm_Relief,1,Conn_01x02_Pin,
"J1_2, J4",JST_PH_S4B-PH-K_1x04_P2.00mm_Horizontal,2,Conn_01x04_Socket,
J1,JST_PH_S4B-PH-SM4-TB_1x04-1MP_P2.00mm_Horizontal,1,Conn_01x04_MountingPin,
"J10, J7",PinHeader_2x04_P1.27mm_Vertical,2,Conn_02x04_Odd_Even,
J11,PinHeader_2x06_P1.27mm_Vertical,1,Conn_02x06_Odd_Even,
"J2_2, J3, J9",PinHeader_1x04_P2.54mm_Vertical,3,Conn_01x04_Socket,
J2,JST_PH_S2B-PH-SM4-TB_1x02-1MP_P2.00mm_Horizontal,1,Conn_01x02_MountingPin,
J5,SolderWire-0.5sqmm_1x02_P4.8mm_D0.9mm_OD2.3mm,1,Conn_01x02_Pin,
J6,PinSocket_1x02_P2.00mm_Vertical,1,Conn_01x02_Pin,
J8,PinHeader_1x04_P2.00mm_Vertical,1,Conn_01x04_Pin,
"L1, L2_2, L3",L_APV_APH0650,3,4.7uH,
L2,L_APV_APH1265,1,4.7uH,
"Q1, Q2, Q3, Q5, Q6",SOT-23,5,AO3400A,
"R1_2, R12, R14, R15, R2_2, R23, R24, R27, R28, R31, R39, R41, R42, R8",0603,14,100k,
R1,0603,1,330k,
"R13, R4_2",0603,2,1.5k,
"R16, R17, R18, R20, R21, R22",0603,6,100k(NC),
R2,0603,1,51k,
"R25, R26, R32, R40, R5, R6",0603,6,1k,
"R29, R33, R34, R35, R36, R4, R45, R7",0603,8,10k,
R3,0603,1,RPORG(1k),
"R30, R38, R43",0603,3,150k,
"R37, R5_2",0603,2,22k,
R44,0603,1,33k,
"U1_2, U9",SOIC-8_3.9x4.9mm_P1.27mm,2,AT24CS08-SSHM,
"U1, U13",SOT-23-6_DBV_TEX,2,TLV61048DBVR,
U10,SOT-563,1,TMP102xxDRL,
"U11, U6",DBV0006A_TEX,2,TPS2552DDBVR,
U12,MFSOP6-4_4.4x3.6mm_P1.27mm,1,TLP127,
U2,SOT-223-3_TabPin2,1,AMS1117-3.3,
U3,LQFP-64_10x10mm_P0.5mm,1,STM32G431RBTx,
U5,SOT-23-6_Handsoldering,1,BQ21040DBV,
U7,TSSOP-14_4.4x5mm_P0.65mm,1,STM32L011D4Px,
U8,SOT-23-5_HandSoldering,1,ME6211C25M5,
Y1,Crystal_C26-LF_D2.1mm_L6.5mm_Horizontal,1,32.768kHz,
Y2,Crystal_DS26_D2.0mm_L6.0mm_Horizontal,1,24Mhz,

## KiCad design 电路/闪光灯转接/FlashAdapter/FlashAdapter.kicad_pcb

Parts:
H1, H2: MountingHole; MountingHole_2.7mm_M2.5
J1: Conn_01x02_Socket; SolderWire-0.75sqmm_1x02_P7mm_D1.25mm_OD3.5mm
U1: PJ-218X-SMT

Connections:
unnamed: J1.1, U1.2
unnamed: J1.2, U1.4

Board: 2 copper layers, 22.0 x 19.0 mm, 4 parts (0 on the bottom side), 2 nets.

## KiCad design 电路/主控器/DispKey/DispKey.kicad_pcb

Parts:
C1, C2: 10uf; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C10, C11, C12: 1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1, D2: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
H1: MountingHole_Pad; MountingHole_3.2mm_M3_DIN965_Pad
H2, H3, H5, H6: MountingHole_Pad; MountingHole_2.7mm_M2.5_DIN965_Pad
J1: Conn_01x02_Pin; SolderWire-0.1sqmm_1x02_P3.6mm_D0.4mm_OD1mm
J2: Conn_01x03_Pin; SolderWire-0.1sqmm_1x03_P3.6mm_D0.4mm_OD1mm
J7, J10: Conn_02x04_Odd_Even; PinHeader_2x04_P1.27mm_Vertical
JP1: SolderJumper_2_Bridged; SolderJumper-2_P1.3mm_Bridged2Bar_RoundedPad1.0x1.5mm
LCD1: LCD1.69_240_280
R1: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R11, R12, R13: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: sw_push_5.8x5.8mm
SW3: Direction3 Pin5
TP1: KEY3; TestPoint_Pad_2.0x2.0mm

Connections:
+2V5: J2.3, JP1.1 (A), SW1.3 (SW2), SW1.6 (SW2)
+3.3V: C1.1, C2.1, J7.7, J10.7, JP1.2 (B), LCD1.2 (VCC), R1.1, R11.2, R12.2, R13.2
/BLK: J7.8, LCD1.8 (BLK)
/D_CS: J7.6, LCD1.7 (CS)
/D_DC: J7.4, LCD1.6 (DC)
/D_RES: J7.2, LCD1.5 (RES)
/D_SCL: J7.5, LCD1.3 (SCL)
/D_SDA: J7.3, LCD1.4 (SDA)
/I2C2_SCL: J10.2
/I2C2_SDA: J10.4
/KEY0: C11.1, J10.6, R12.1, SW3.C
/KEY1: C10.1, J10.8, R11.1, SW3.D
/KEY2: C12.1, J10.5, R13.1, SW3.B
/KEY3: D1.2 (A), J10.3, TP1.1
/WKUP: J2.2, SW1.2 (COM), SW1.5 (COM)
GND: C1.2, C2.2, C10.2, C11.2, C12.2, H1.1, H2.1, H3.1, H5.1, H6.1, J2.1, J7.1, J10.1, LCD1.1 (GND), LCD1.H (Mount), SW1.1 (SW1), SW1.4 (SW1), SW3.A
unnamed: D1.1 (K), R1.2
unnamed: D2.2 (A), J1.2
unnamed: D2.1 (K), J1.1

Notes on the sheet:
电源按键
显示&按键

Board: 2 copper layers, 77.0 x 61.5 mm, 25 parts (5 on the bottom side), 17 nets.

File 电路/主控器/DispKey/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C2",0805,2,10uf,
"C10, C11, C12",0603,3,1uF,
"D1, D2",0805,2,LED,
J1,SolderWire-0.1sqmm_1x02_P3.6mm_D0.4mm_OD1mm,1,Conn_01x02_Pin,
"J10, J7",PinHeader_2x04_P1.27mm_Vertical,2,Conn_02x04_Odd_Even,
J2,SolderWire-0.1sqmm_1x03_P3.6mm_D0.4mm_OD1mm,1,Conn_01x03_Pin,
LCD1,LCD1.69_240_280,1,~,
R1,0603,1,10k,
"R11, R12, R13",0603,3,100k,
SW1,sw_push_5.8x5.8mm,1,~,
SW3,Direction3 Pin5,1,~,
TP1,TestPoint_Pad_2.0x2.0mm,1,KEY3,

## Code that names these connections

File 代码（弃用）/Maincontroller/Maincontroller.ioc (part):

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Mcu.Name=STM32G431R(6-8-B)Tx
Mcu.Package=LQFP64
Mcu.UserName=STM32G431RBTx
PA0.GPIOParameters=GPIO_Label
PA0.GPIO_Label=KEY0
PA0.Signal=GPXTI0
PA1.GPIOParameters=GPIO_Label
PA1.GPIO_Label=KEY1
PA1.Signal=GPXTI1
PA11.Mode=Device
PA11.Signal=USB_DM
PA12.Mode=Device
PA12.Signal=USB_DP
PA13.Mode=Serial_Wire
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Serial_Wire
PA14.Signal=SYS_JTCK-SWCLK
PA15.GPIOParameters=GPIO_Label
PA15.GPIO_Label=FLASH_Trig
PA15.Signal=GPIO_Output
PA2.Mode=Asynchronous
PA2.Signal=USART2_TX
PA3.Mode=Asynchronous
PA3.Signal=USART2_RX
PA4.GPIOParameters=GPIO_Label
PA4.GPIO_Label=KEY2
PA4.Signal=GPXTI4
PA5.GPIOParameters=GPIO_Label
PA5.GPIO_Label=SHUT_Trig
PA5.Signal=GPIO_Input
PA6.GPIOParameters=GPIO_Label
PA6.GPIO_Label=EJCMT_EN
PA6.Signal=GPIO_Output
PA7.GPIOParameters=GPIO_Label
PA7.GPIO_Label=KEY3
PA7.Signal=GPXTI7
PA8.Mode=I2C
PA8.Signal=I2C2_SDA
PA9.Mode=I2C
PA9.Signal=I2C2_SCL
PB0.Mode=IN15-Single-Ended
PB0.Signal=ADC1_IN15
PB10.Mode=Asynchronous
PB10.Signal=USART3_TX
PB11.Mode=Asynchronous
PB11.Signal=USART3_RX
PB12.GPIOParameters=GPIO_Label
PB12.GPIO_Label=P2C0
PB12.Signal=GPXTI12
PB13.GPIOParameters=GPIO_Label
PB13.GPIO_Label=P2C1
PB13.Signal=GPXTI13
PB14.GPIOParameters=GPIO_Label
PB14.GPIO_Label=C2P0
PB14.Signal=GPIO_Output
PB15.GPIOParameters=GPIO_Label
PB15.GPIO_Label=C2P1
PB15.Signal=GPIO_Output
PB3.GPIOParameters=GPIO_Label
PB3.GPIO_Label=D_SCL
PB3.Mode=Simplex_Bidirectional_Master
PB3.Signal=SPI1_SCK
PB5.GPIOParameters=GPIO_Label
PB5.GPIO_Label=D_SDA
PB5.Mode=Simplex_Bidirectional_Master
PB5.Signal=SPI1_MOSI
PB6.GPIOParameters=GPIO_Label
PB6.GPIO_Label=D_RES
PB6.Signal=GPIO_Output
PB7.GPIOParameters=GPIO_Label
PB7.GPIO_Label=D_DC
PB7.Signal=GPIO_Output
PB9.GPIOParameters=GPIO_Label
PB9.GPIO_Label=D_CS
PB9.Signal=GPIO_Output
PC0.Mode=Asynchronous
PC0.Signal=LPUART1_RX
PC1.Mode=Asynchronous
PC1.Signal=LPUART1_TX
PC10.Mode=Full_Duplex_Master
PC10.Signal=SPI3_SCK
PC11.Mode=Full_Duplex_Master
PC11.Signal=SPI3_MISO
PC12.Mode=Full_Duplex_Master
PC12.Signal=SPI3_MOSI
PC14-OSC32_IN.Mode=LSE-External-Oscillator
PC14-OSC32_IN.Signal=RCC_OSC32_IN
PC15-OSC32_OUT.Mode=LSE-External-Oscillator
PC15-OSC32_OUT.Signal=RCC_OSC32_OUT
PC3.GPIOParameters=GPIO_Label
PC3.GPIO_Label=PWR_SENS
PC3.Signal=GPXTI3
PC4.GPIOParameters=GPIO_Label
PC4.GPIO_Label=PWR_EN2
PC4.Signal=GPIO_Output
PC8.Mode=I2C
PC8.Signal=I2C3_SCL
PC9.Mode=I2C
PC9.Signal=I2C3_SDA
PD2.GPIOParameters=GPIO_Label
PD2.GPIO_Label=PD2
PD2.Signal=GPIO_Output
PF0-OSC_IN.Mode=HSE-External-Oscillator
PF0-OSC_IN.Signal=RCC_OSC_IN
PF1-OSC_OUT.Mode=HSE-External-Oscillator
PF1-OSC_OUT.Signal=RCC_OSC_OUT
RCC.HSE_VALUE=24000000
RCC.SYSCLKFreq_VALUE=170000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=custom

File code/PowerManage2/PowerManage2.ioc (part):

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Mcu.Name=STM32L011D(3-4)Px
Mcu.Package=TSSOP14
Mcu.UserName=STM32L011D4Px
PA0-CK_IN.GPIOParameters=GPIO_PuPd,GPIO_Label
PA0-CK_IN.GPIO_Label=WKUP
PA0-CK_IN.GPIO_PuPd=GPIO_PULLDOWN
PA0-CK_IN.Signal=GPIO_Input
PA1.GPIOParameters=GPIO_Speed,GPIO_PuPd,GPIO_Label
PA1.GPIO_Label=P2C0
PA1.GPIO_PuPd=GPIO_PULLDOWN
PA1.GPIO_Speed=GPIO_SPEED_FREQ_LOW
PA1.Signal=GPIO_Output
PA10.GPIOParameters=GPIO_PuPd,GPIO_Label
PA10.GPIO_Label=C2P1
PA10.GPIO_PuPd=GPIO_PULLUP
PA10.Signal=GPIO_Input
PA13.Mode=Serial_Wire
PA13.Signal=SYS_SWDIO
PA14.Mode=Serial_Wire
PA14.Signal=SYS_SWCLK
PA4.GPIOParameters=GPIO_Label
PA4.GPIO_Label=P2C1
PA4.Signal=GPIO_Output
PA7.GPIOParameters=GPIO_Label
PA7.GPIO_Label=PWR_KEY
PA7.Signal=GPIO_Input
PA9.GPIOParameters=GPIO_PuPd,GPIO_Label
PA9.GPIO_Label=C2P0
PA9.GPIO_PuPd=GPIO_PULLUP
PA9.Signal=GPIO_Input
PC14-OSC32_IN.GPIOParameters=GPIO_PuPd,GPIO_Label
PC14-OSC32_IN.GPIO_Label=PWR_LED
PC14-OSC32_IN.GPIO_PuPd=GPIO_PULLUP
PC14-OSC32_IN.Signal=GPIO_Output
PC15-OSC32_OUT.GPIOParameters=PinState,GPIO_PuPd,GPIO_Label,GPIO_ModeDefaultOutputPP
PC15-OSC32_OUT.GPIO_Label=PWR_EN
PC15-OSC32_OUT.GPIO_ModeDefaultOutputPP=GPIO_MODE_OUTPUT_OD
PC15-OSC32_OUT.GPIO_PuPd=GPIO_PULLUP
PC15-OSC32_OUT.PinState=GPIO_PIN_SET
PC15-OSC32_OUT.Signal=GPIO_Output
RCC.HSE_VALUE=8000000
RCC.SYSCLKFreq_VALUE=16000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=custom

## Commit log (part)

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2025-02-23 消除地板和吐片外壳之间干涉，加固侧边安装孔
2025-02-23 更新片仓中框、片仓地板
2025-06-23 ZUI init
2025-06-29 电源显示ok
2025-06-29 修复了显示用的数组使用局部变量的问题
2025-07-01 吐片正常（废片测试）
2025-07-01 测距正常，下一步尽量改成用接收到idle，来防止误码。
2025-07-02 显示中加入核心以及PCB温度；后续应考虑测距使用接收到空闲中断避免误码导致中断。
2025-07-16 测距改成300ms一次，解决了测距卡死的问题
2025-07-16 定时器计数逻辑修改
2025-07-16 修复定时器逻辑问题
2025-07-18 吐片后必须要重启电源才能测距
2025-07-19 Rev1.0版本可正常工作
2025-09-27 第二代机械结构ok
2025-11-23 闪关灯功能OK 准备给电机加一个斜坡
2025-11-23 电机软起动加入，效果有限无法防止激光雷达下电
2025-12-25 闪光灯ok
2026-01-05 闪光已经就绪，至此基本功能全部OK
2026-01-05 清理仓库
2026-01-05 Add License
2026-01-21 优化外壳与5V外部供电电路选择逻辑
2026-01-21 主控升级至Rev1.2，电机驱动 Rev1.1
    电机驱动修改后采用Mosfet控制高侧电源通路。主控配套进行了更改。
2026-02-02 更新了电机驱动以及主控器PCB
2026-02-03 测试Rev1.2版本PCB，吐片导致测距停止问题已经修复
    测试Rev1.2版本PCB
    1. 原有引脚可以直接兼容G474芯片
    2. 吐片导致测距停止问题已经修复
    目前吐片的PWM加载方式可以进行调整
2026-02-03 硬件1.3版本，调整闪光灯为默认过MCU
2026-02-08 机械：优化吐片机械结构；代码：吐片电机及屏幕显示逻辑调整，ADC采样逻辑调整
    机械：
    1. 吐片下巴处增加导向齿轮
    代码：
    1. 电机启动斜坡加载速率调整
    2. 充电主控芯片采用外部供电时关闭屏幕及LED闪烁
    3. 电池ADC增加一阶低通滤波
2026-02-14 所有修改，两盒底片测试OK
2026-02-27 新版本主片仓以及镜头机构设计，待测试
    主片仓与吐片钣金连接位置内移1.25mm；
    镜头机构重新设计连接机构，期望消除黑底；
    删除了结构吐片机构文件夹（内容早已合并入片仓总成，应删除）
2026-02-27 修复对焦距离问题
2026-03-06 重新整理打印文件
2026-03-08 新版本PM，解决底部偏暗
2026-03-14 增加多种尺寸的齿轮定位
2026-03-14 原本齿轮定位尺寸ok不应再加高度；修改电机驱动电路，但是电机驱动电路未完全ok
2026-03-14 驱动电路升级至R1.2 未验证
    R1.2 升压二极管改为SS34；储能电容改为连接原始电源GND；电路板改为单面布局
2026-03-19 开始设计全息取景器
2026-03-19 结构CNC条件具备，尚未调整螺纹孔
2026-03-20 添加 Keil 6 CMSIS 配置文件
2026-03-20 Remove code folder, moved to separate software repo
2026-03-20 项目中的代码文件迁出至其它仓库
2026-03-20 移除子模块配置
2026-03-20 更新 README，添加代码仓库链接
2026-03-20 将代码仓库链接移到 README 顶部
2026-03-21 迁移硬件设计文件至独立仓库
    - 将电路设计文件（KiCad 项目）移至 PolaMiyaHardware 仓库
    - 将结构文件（STL/STEP/SolidWorks）移至 PolaMiyaHardware 仓库
    - 更新 ReadMe.md 添加仓库说明和已实现功能
    - 本仓库保留项目整体说明文档
2026-03-30 更新样片
2026-03-30 更新样片展示
2026-03-30 展示相机外观
